# Keil uVision project nucleo_mk.uvprojx, settings and files
target Nucleo_MK (ARM-ADS)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo_mk
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32L4_NUCLEO
  c include: .\lib\BSP;.\lib\CMSIS;.\lib;.\lib\STM32HALL4\Inc\Legacy;.\lib\STM32HALL4\Inc;.\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group source
    ./source/: main.c led.c hal.c uart.c itoa.c timer.c mk_term.c i2c.c kompas.c lsm9ds0.c
  group lib
    ./lib/CMSIS/: system_stm32l4xx.c startup_stm32l476xx.s
    ./lib/STM32HALL4/Src/: stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_dfsdm.c
    ./lib/: stm32l4xx_it.c
    ./lib/BSP/: stm32l4xx_nucleo.c
